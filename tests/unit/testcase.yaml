## tests/unit/testcase.yaml
```yaml
tests:
  specialized.unit.portable_logic:
    type: unit
    platform_allow: unit_testing
```
